## Kconfig
```kconfig
config CONFIG_SECURITY_LSM_WRAP
	bool "Simple LSM Module example"
	depends on SECURITY && BLOCK
	help
	  Simple and dirty LSM module example
```
